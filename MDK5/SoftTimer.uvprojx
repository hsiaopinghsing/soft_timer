# Keil uVision project SoftTimer.uvprojx, settings and files
target SoftTimer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SoftTimer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware;..\Libraries\CMSIS;..\Libraries\CMSIS\core;..\Libraries\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c soft_timer.c stm32f10x_it.c debug.c demo.c
    ../: user_timer.c
  group Hardware
    ../Hardware/: timer.c usart.c
  group STDLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
    ../Libraries/CMSIS/core/: core_cm3.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group Log
    ../: log.txt
